# Keil uVision project internal-RAM-data-block-transfer-with-indirect-addressing.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC841 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: internal-RAM-data-block-transfer-with-indirect-addressing
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.a51
